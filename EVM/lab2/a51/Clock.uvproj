# Keil uVision project Clock.uvproj, settings and files
target Clock (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Clock
  c flags: Optimize=8 SizeSpeed=1
  group Src
    ./: Clock.a51
